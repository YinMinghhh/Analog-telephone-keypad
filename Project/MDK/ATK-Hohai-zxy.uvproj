# Keil uVision project ATK-Hohai-zxy.uvproj, settings and files
target zxy-s_Target (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: ATK-Hohai-zxy +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Libraries\libraries;..\USER\inc;..\CODE;..\..\Libraries\zxy_libraries
  group start_up
    ../../Libraries/libraries/: board.c board.h common.c common.h STARTUP.A51
  group zxy_libraries
    ../../Libraries/zxy_libraries/: TIM.c TIM.h UART.c UART.h
  group user_c
    ../USER/src/: isr.c main.c modules.c
  group user_h
    ../USER/inc/: isr.h modules.h
  group APP_KeyBoard
    ../CODE/: KeyBoard.c KeyBoard.h
